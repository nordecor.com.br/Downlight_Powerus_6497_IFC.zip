Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-04-29T20:57:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 29 20:57:47 2025 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\f0b5865c-b453-43ac-8062-ba82e2c86ccb\e814da0e-2b8b-4efc-b832-921f7bfc1875\ifc * Database version: 5507 * Database creation date: Tue Apr 29 20:57:46 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 29 20:57:46 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 29 20:57:46 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcFlowTerminal: 6497, Downlight_Powerus_6497_Nordecor_IFC:6497:329217
In: Nível 1
Type - Material: LED, Plástico - Policarbonato - Translúcido, Metal - Alumínio - preto
Type - Cotas - Altura da luminária: 46 mm; Comprimento da luminária: 98 mm; Comprimento do nicho: 92 mm; Largura da luminária: 53 mm; Largura do nicho: 46 mm
Type - Dados - Data da atualização: 29/04/2025; Versão: 1
Type - Dados de identidade - Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Downlight de embutir com borda, acabamento corpo e lente preta, 3 focos, LED 6W, 3000K 35º; Desenvolvedor: Check BIM; Fabricante: Nordecor; Fixação: Molas; Garantia: 2 Anos; Grau de proteção: IP20; Localização: Camboriú-SC / Brasil; Modelo: 6497; Nome do tipo: 6497; Número OmniClass: 23.80.70.11.14.14; Tipo de imagem: Imagem raster: 6497.png; Título OmniClass: Uplights; URL: https://nordecor.com.br; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/downlight-led-de-embutir-powerus-dir/
Type - Elétrico - Comentários de voltagem: 100-240V; Fator de potência - Luminária: 0.5; Lâmpada: LED
Type - Elétrico - Cargas - Carga aparente - Luminária: 0 W
Type - Engenharia elétrica - Voltagem - Luminária: 0 V
Type - Estrutural - Peso: 0
Type - Fotométricos - Fluxo luminoso: 540 lm; Grau de abertura: 35 deg; IRC (RA): >90; Potência: 6 W; SDMC: <3; Temperatura de cor: 3000 K; UGR: <9
Type - Gráficos - Simbologia: Imagem raster: 6497 2D.png
Type - Materiais e acabamentos - Difusor: Plástico - Policarbonato - Translúcido; Luminária: Metal - Alumínio - preto
Type - Outros - Categoria: Luminárias; Branco: yes; Nome da família: Downlight_Powerus_6497_Nordecor_IFC
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Pset_DistributionFlowElementCommon - Reference: 6497; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Nordecor
Cotas - Ângulo de inclinação: 0 deg; Área: 0.0199702 m2; Volume: 0.000100028 m3
Dados de identidade - Marca: 1
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Ângulo luminária: 0 deg; Família: Downlight_Powerus_6497_Nordecor_IFC: 6497; Família e tipo: Downlight_Powerus_6497_Nordecor_IFC: 6497; ID de tipo: Downlight_Powerus_6497_Nordecor_IFC: 6497; Tipo: Downlight_Powerus_6497_Nordecor_IFC: 6497
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
